# Keil uVision project 110-STM32F1-Time Data Logger Library using RTC DS3232 and EEPROM AT24C32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 110-STM32F1-Time Data Logger Library using RTC DS3232 and EEPROM AT24C32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c AT24C_Drive.c AT24C_Drive.h data_logger.c data_logger.h help_func.c help_func.h systick_time.c systick_time.h
  group Drivers
    ./: DS3231_Drive.c DS3231_Drive.h gp_drive.c gp_drive.h i2c_drive.c i2c_drive.h oled_drive.c oled_drive.h uart_drive.h uart_drive.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
